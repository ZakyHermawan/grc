options:
  parameters:
    current_workflow: cpp_qt_gui_workflow
    generate_options: qt_gui
    generator_class_name: CppTopBlockGenerator
    generator_module: gnuradio.grc.workflows.cpp_qt_gui
    id: horn
    output_language: cpp
    title: horn
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.0.0git-1489-g07ad53d3
