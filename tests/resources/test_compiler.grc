options:
  parameters:
    generate_options: no_gui
    generator_class_name: TopBlockGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: top_block
    output_language: python
    placement: (0, 0)
    run_options: run
  states: {}

blocks:
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: (0, 0, 0)
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_null_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_add_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.0.0git-1481-g81a99d68
