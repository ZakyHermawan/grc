options:
  parameters:
    generate_options: no_gui
    generator_class_name: TopBlockGenerator
    generator_module: gnuradio_companion.workflows.python_nogui
    id: test_python_jinja
    output_language: python
    template_engine: jinja
    title: Test Python Jinja
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-794-g97ecec36
