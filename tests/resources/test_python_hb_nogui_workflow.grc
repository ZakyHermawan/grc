options:
  parameters:
    author: rootkid
    current_workflow: python_hb_nogui_workflow
    generate_options: hb
    generator_class_name: HierBlockGenerator
    generator_module: gnuradio_companion.workflows.python_hb_nogui
    id: test_python_hb_nogui_workflow
    output_language: python
    placement: (0, 0)
    title: python hb no gui
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.0.0git-1489-g07ad53d3
