options:
  parameters:
    author: rootkid
    current_workflow: python_hb_qt_gui_workflow
    generate_options: hb_qt_gui
    generator_class_name: QtHierBlockGenerator
    generator_module: gnuradio_companion.workflows.python_hb_qt_gui
    id: test_python_hb_qt_gui_workflow
    output_language: python
    placement: (0, 0)
    title: python hb qt gui
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.0.0git-1489-g07ad53d3
